# IAR project CC3000 Host Driver.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430AFE253 MSP430AFE253
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MDNS_ADVERTISE_HOST; CC3000_UNENCRYPTED_SMART_CONFIG
  ICC430.CCDiagSuppress: Pa039
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\inc
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  group (top)
    ../Source/CC3000HostDriver/: cc3000_common.c cc3000_common.h error_codes.h evnt_handler.c evnt_handler.h hci.c hci.h host_driver_version.h netapp.c netapp.h nvmem.c nvmem.h security.c security.h socket.c socket.h wlan.c wlan.h
