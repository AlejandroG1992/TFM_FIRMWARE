# IAR project BasicWiFiApplication.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430AFE253 MSP430AFE253
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: CC3000_UNENCRYPTED_SMART_CONFIG
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\\HyperTerminal Driver; ..\Source\\CC3000 Spi; ..\Source\inc
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: Z:\CC3000+MSP430AFE253\Basic WiFi Application IAR\lnk430afe253.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Source/BasicWiFi Application/: application_version.h basic_wifi_application.c board.c board.h
  group Library
    Debug/Exe/: CC3000 Host Driver.r43 CC3000_Spi.r43 HyperTerminalDriver.r43
