# IAR project Backup of CC3000_Spi.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MDNS_ADVERTISE_HOST
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\inc; ..\Source\BasicWiFi Application
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.ADefines: NDEBUG
  group (top)
    ../Source/CC3000 Spi/: spi.c spi_version.h
