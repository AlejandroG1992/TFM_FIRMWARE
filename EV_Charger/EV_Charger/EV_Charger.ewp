# IAR project EV_Charger.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430AFE253 MSP430AFE253
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: CC3000_UNENCRYPTED_SMART_CONFIG
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\\HyperTerminal Driver; ..\Source\\CC3000 Spi; ..\Source\inc
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: Z:\EV_Charger\EV_Charger\lnk430afe253.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NDEBUG
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Source/EV_Charger/: Analog_sampling.c Analog_sampling.h board.c board.h Charger_States.c Charger_States.h ControlPilot.c ControlPilot.h FlashMemory.c FlashMemory.h Listener.c Listener.h Main.c Main.h SmartConfig.c SmartConfig.h Wattmeter.c Wattmeter.h Wifi.c Wifi.h
  group Library
    Debug/Exe/: CC3000 Host Driver.r43 CC3000_Spi.r43
