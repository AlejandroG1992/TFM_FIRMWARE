<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\Debug\Exe\CC3000 Host Driver.r43</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Debug\Exe\CC3000_Spi.r43</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Analog_sampling.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Analog_sampling.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\board.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\board.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Charger_States.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Charger_States.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\ControlPilot.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\ControlPilot.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\FlashMemory.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\FlashMemory.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Listener.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Listener.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Main.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\SmartConfig.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\SmartConfig.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Wattmeter.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Wattmeter.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Wifi.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\Source\EV_Charger\Wifi.h</name>
  </file>
</project>


